# Keil uVision project AD_ADXL345_CAN.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AD_ADXL345_CAN +hex
  AfterMake: D:\Keil\ARM\BIN40\fromelf.exe --bin -o .\USER\AD_ADXL345_CAN.bin .\USER\AD_ADXL345_CAN.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\SYSTEM\delay;.\SYSTEM\IIC;.\SYSTEM\sys;.\SYSTEM\usart;.\SYSTEM\ADXL345;.\SYSTEM\AD;.\SYSTEM\can;.\SYSTEM\IAP
  memory RVCT4: ROM 0x8004000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: cortexm3_macro.s startup_stm32f10x_hd.s
    C:/Keil/ARM/RV31/LIB/ST/: STM32F10xR.LIB
  group SYSTEM
    ./SYSTEM/AD/: AD.c
    ./SYSTEM/ADXL345/: adxl345.c
    ./SYSTEM/can/: CAN.c
    ./SYSTEM/sys/: clock_init.c sys.c
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/IIC/: myiic.c
    C:/Keil/ARM/RV31/LIB/ST/STM32F10x/: stm32f10x_adc.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
  group USER
    ./USER/: main.c
  group IAP
    ./SYSTEM/IAP/: CRC32.c flash.c iap.c timer.c
